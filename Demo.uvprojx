# Keil uVision project Demo.uvprojx, settings and files
target Version1.0 (ARM-ADS)
  device: ADuCM360 Analog Devices
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(16000000) ELITTLE
  output: Demo
  c flags: Optim=1
  c include: .\src;.\common;.\src\threads
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group System
    ./src/: main.c utils.c
  group Threads
    ./src/threads/: thread_led.c thread_uart.c thread_adc.c thread_adc0.c thread_i2c.c
  group HAL
    ./src/: led.c uart.c adc.c timer.c i2c.c adc0.c mpu6050.c
  group aducm361_lib
    ./common/: AdcLib.c ClkLib.c DacLib.c DioLib.c DmaLib.c FeeLib.c GptLib.c I2cLib.c IexcLib.c IntLib.c PwmLib.c PwrLib.c RstLib.c SpiLib.c UrtLib.c WdtLib.c WutLib.c
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS_RTX/Lib/ARM/: RTX_CM3.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::Device
    RTE/Device/ADuCM360/: startup_ADuCM360.s system_ADuCM360.c
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.74.0, Device:Startup 1.0.0
